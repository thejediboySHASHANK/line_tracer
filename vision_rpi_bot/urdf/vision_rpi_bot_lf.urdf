Commit message: Robust model integration

File: vision_rpi_bot/urdf/vision_rpi_bot_lf.urdf (robot description, URDF)
Before this commit: robot vision_rpi_bot, 8 links, 7 joints
Joints:
- joint camera_joint: origin xyz=0 -0.24 0.2 rpy=0.0 0.65 -1.57 -> xyz=0 -0.24 0.2 rpy=0.0 1.0 -1.57
